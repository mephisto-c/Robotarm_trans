# Keil uVision project 0Project.uvprojx, settings and files
target multi_func (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: multi_func +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\HARDWARE\KEY;..\HARDWARE\LCD_ILI9328;..\HARDWARE\LED;..\HARDWARE\TOUCH;..\SYSTEM;..\USER;..\HARDWARE\FLASH;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\HARDWARE\24CXX;..\HARDWARE\ADXL345;..\HARDWARE\SRAM;..\HARDWARE\SD;..\HARDWARE\TPAD;..\HARDWARE\DS18B20;..\HARDWARE\REMOTE;..\HARDWARE\RTC;..\TEXT;..\MALLOC;..\FATFS;..\HARDWARE\SDIO_SD;..\HARDWARE\VS10XX;..\USMART;..\HARDWARE\WDG;..\HARDWARE\WKUP;..\HARDWARE\DMA;..\HARDWARE\NRF24L01;..\HARDWARE\ADC;..\HARDWARE\CAN;..\HARDWARE\DAC;..\HARDWARE\DHT11;..\HARDWARE\DMA;..\HARDWARE\EXTI;..\HARDWARE\JOYPAD;..\HARDWARE\NRF24L01;..\HARDWARE\OV7670;..\HARDWARE\PS2;..\HARDWARE\RDA5820;..\HARDWARE\REMOTE;..\HARDWARE\RS485;..\HARDWARE\STMFLASH;..\HARDWARE\SUPER_WAVE;..\HARDWARE\TIMER;..\HARDWARE\TPAD;..\IMAGE2LCD;..\T9INPUT;..\ATKNCR;..\USB\CONFIG;..\USB\LIB;..\FWLib\inc;..\T9INPUT;..\APP;..\PICTURE;..\HARDWARE\tim;..\GUI;..\HARDWARE;..\HARDWARE;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: startup_stm32f10x_hd.s main.c bsp.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c xprintf.c malloc.c
  group FWLIB
    ../FWLib/: STM32F10xR.LIB
  group HARDWARE
    ../HARDWARE/: key.c
    ../HARDWARE/TIMER/: timer.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group APP
    ../APP/: steer.c
